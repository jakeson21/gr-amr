options:
  parameters:
    category: '[AMR]'
    generate_options: hb
    id: amr_rx_heir
    output_language: python
    title: AMR Rx Heir
  states: {}

blocks:
- name: amr_fsk_demod_ff_0
  id: amr_fsk_demod_ff
  parameters:
    center_freq: center_freq
    period: period
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: mag_trigger_level
    init: '0'
    low: mag_trigger_level-5
  states: {}
- name: center_freq
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: mag_trigger_level
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: detect
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: power
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: period
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '0'
  states: {}

connections:
- [amr_fsk_demod_ff_0, pdu, pad_sink_2, in]
- [blocks_complex_to_magphase_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_magphase_0, '1', amr_fsk_demod_ff_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_threshold_ff_0, '0']
- [blocks_nlog10_ff_0, '0', pad_sink_1, '0']
- [blocks_threshold_ff_0, '0', amr_fsk_demod_ff_0, '1']
- [blocks_threshold_ff_0, '0', pad_sink_0, '0']
- [pad_source_1, '0', blocks_delay_0, '0']
- [pad_source_1, '0', blocks_multiply_conjugate_cc_0, '0']

metadata:
  file_format: 1
