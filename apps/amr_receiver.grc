options:
  parameters:
    generate_options: qt_gui
    id: amr_receiver
    output_language: python
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '4'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: variable_qtgui_Fc*1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: variable_qtgui_Fc
  id: variable_qtgui_range
  parameters:
    label: Center Frequency (kHz)
    start: '89'
    step: '0.001'
    stop: '930'
    value: '908.122'
  states: {}
- name: variable_qtgui_Gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: variable_trigger_level
  id: variable_qtgui_range
  parameters:
    label: Trigger Level
    start: '-80'
    step: '1'
    stop: '20'
    value: '-17'
  states: {}
- name: amr_packet_detector_0
  id: amr_packet_detector
  parameters:
    sample_rate: samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: variable_trigger_level
    init: '0'
    low: variable_trigger_level-2.0
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: '[-1.32218580e-03+0.00000000e+00j,-7.69165817e-04-1.13774280e-03j, 4.70769845e-04-1.40938578e-03j, 1.45596554e-03-6.07222859e-04j, 1.43932680e-03+6.51552628e-04j, 4.54243736e-04+1.38988501e-03j,-6.88762261e-04+1.03642492e-03j,-1.02692028e-03-9.36586647e-05j,-2.33724984e-04-1.00954137e-03j, 1.06157602e-03-8.30543590e-04j, 1.73035887e-03+4.57077541e-04j, 1.06213804e-03+1.91303497e-03j,-5.96231096e-04+2.36029493e-03j,-2.05219301e-03+1.36242280e-03j,-2.21861069e-03-3.59687047e-04j,-1.03895412e-03-1.47611117e-03j, 4.18726998e-04-1.15497672e-03j, 8.36788075e-04+1.98192844e-04j,-2.10610604e-04+1.23722543e-03j,-1.83075585e-03+8.10663236e-04j,-2.51321844e-03-1.00764763e-03j,-1.40882521e-03-2.89545488e-03j, 8.92553091e-04-3.33731076e-03j, 2.77918097e-03-1.89880747e-03j, 2.92302465e-03+3.62798096e-04j, 1.39564324e-03+1.73533941e-03j,-3.59490096e-04+1.27184419e-03j,-7.16731803e-04-3.85542794e-04j, 7.38267059e-04-1.49577062e-03j, 2.77481686e-03-6.67484748e-04j, 3.45426380e-03+1.90210175e-03j, 1.73134007e-03+4.44608978e-03j,-1.57337859e-03+4.96917784e-03j,-4.28467597e-03+2.88929715e-03j,-4.55991569e-03-3.63942883e-04j,-2.44600733e-03-2.38632865e-03j, 1.64928756e-05-1.75971039e-03j, 3.89346582e-04+6.27596593e-04j,-2.03082307e-03+2.11204679e-03j,-5.32324505e-03+4.24726467e-04j,-6.25881875e-03-4.16569024e-03j,-2.99854987e-03-8.63979857e-03j, 3.01045726e-03-9.44930274e-03j, 7.78286001e-03-5.58336909e-03j, 7.96186700e-03+1.56468553e-04j, 3.93161125e-03+3.15032311e-03j,-3.20525468e-06+9.64784294e-04j, 9.30782071e-04-3.98761294e-03j, 7.44555543e-03-5.87250197e-03j, 1.46365764e-02-3.81840642e-04j, 1.54486273e-02+1.07720365e-02j, 6.88600235e-03+2.01480276e-02j,-6.34411402e-03+2.03385407e-02j,-1.47154144e-02+1.08790185e-02j,-1.19309075e-02+2.90007995e-05j,-1.66908389e-03-1.34604348e-03j, 3.56951908e-03+1.01905352e-02j,-7.76689808e-03+2.50976789e-02j,-3.48175601e-02+2.58663689e-02j,-6.09595053e-02+5.08625191e-04j,-6.32023902e-02-4.52982575e-02j,-2.89958991e-02-8.78167665e-02j, 3.18128552e-02-9.89654395e-02j, 8.98939539e-02-6.55263475e-02j, 1.13740378e-01+0.00000000e+00j, 8.98939539e-02+6.55263475e-02j, 3.18128552e-02+9.89654395e-02j,-2.89958991e-02+8.78167665e-02j,-6.32023902e-02+4.52982575e-02j,-6.09595053e-02-5.08625191e-04j,-3.48175601e-02-2.58663689e-02j,-7.76689808e-03-2.50976789e-02j, 3.56951908e-03-1.01905352e-02j,-1.66908389e-03+1.34604348e-03j,-1.19309075e-02-2.90007995e-05j,-1.47154144e-02-1.08790185e-02j,-6.34411402e-03-2.03385407e-02j, 6.88600235e-03-2.01480276e-02j, 1.54486273e-02-1.07720365e-02j, 1.46365764e-02+3.81840642e-04j, 7.44555543e-03+5.87250197e-03j, 9.30782071e-04+3.98761294e-03j,-3.20525468e-06-9.64784294e-04j, 3.93161125e-03-3.15032311e-03j, 7.96186700e-03-1.56468553e-04j, 7.78286001e-03+5.58336909e-03j, 3.01045726e-03+9.44930274e-03j,-2.99854987e-03+8.63979857e-03j,-6.25881875e-03+4.16569024e-03j,-5.32324505e-03-4.24726467e-04j,-2.03082307e-03-2.11204679e-03j, 3.89346582e-04-6.27596593e-04j, 1.64928756e-05+1.75971039e-03j,-2.44600733e-03+2.38632865e-03j,-4.55991569e-03+3.63942883e-04j,-4.28467597e-03-2.88929715e-03j,-1.57337859e-03-4.96917784e-03j, 1.73134007e-03-4.44608978e-03j, 3.45426380e-03-1.90210175e-03j, 2.77481686e-03+6.67484748e-04j, 7.38267059e-04+1.49577062e-03j,-7.16731803e-04+3.85542794e-04j,-3.59490096e-04-1.27184419e-03j, 1.39564324e-03-1.73533941e-03j, 2.92302465e-03-3.62798096e-04j, 2.77918097e-03+1.89880747e-03j, 8.92553091e-04+3.33731076e-03j,-1.40882521e-03+2.89545488e-03j,-2.51321844e-03+1.00764763e-03j,-1.83075585e-03-8.10663236e-04j,-2.10610604e-04-1.23722543e-03j, 8.36788075e-04-1.98192844e-04j, 4.18726998e-04+1.15497672e-03j,-1.03895412e-03+1.47611117e-03j,-2.21861069e-03+3.59687047e-04j,-2.05219301e-03-1.36242280e-03j,-5.96231096e-04-2.36029493e-03j, 1.06213804e-03-1.91303497e-03j, 1.73035887e-03-4.57077541e-04j, 1.06157602e-03+8.30543590e-04j,-2.33724984e-04+1.00954137e-03j,-1.02692028e-03+9.36586647e-05j,-6.88762261e-04-1.03642492e-03j, 4.54243736e-04-1.38988501e-03j, 1.43932680e-03-6.51552628e-04j, 1.45596554e-03+6.07222859e-04j, 4.70769845e-04+1.40938578e-03j,-7.69165817e-04+1.13774280e-03j]'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      908.122
      908.10
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq*0.
    fftsize: '2048'
    grid: 'True'
    showports: 'True'
    type: complex
    update_time: '0.02'
    ymax: '-50'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '3000'
    srate: samp_rate
    tr_level: variable_trigger_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '20'
    ymin: '-50'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"Bits"'
    size: '3000'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '3000'
    srate: samp_rate
    tr_level: 10.0**(variable_trigger_level/20.0)
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq*0
    fftsize: '256'
    grid: 'True'
    int_max: '-10'
    int_min: '-90'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate*N
    center_freq0: uhd.tune_request(center_freq, samp_rate)
    dc_offs_enb0: auto
    dev_addr: '"serial=3102419"'
    gain0: variable_qtgui_Gain
    iq_imbal_enb0: auto
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [amr_packet_detector_0, pdu, blocks_message_debug_0, print]
- [blocks_complex_to_mag_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_threshold_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_threshold_ff_0, '0', amr_packet_detector_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_0, '0']
- [fft_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_1, '0', fft_filter_xxx_0, '0']
- [uhd_usrp_source_1, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
