options:
  parameters:
    generate_options: qt_gui
    id: amr_receiver2
    output_language: python
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '2'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: variable_qtgui_Fc*1e6
  states: {}
- name: mag_trigger_level
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,1,1,1]'
    label: Mag Trigger Level
    start: '-60'
    step: '1'
    stop: '0'
    value: '-15'
  states: {}
- name: phase_trigger_level
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,1,1,1]'
    label: Phase Trigger Level
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: samp_rate_2
  id: variable
  parameters:
    value: 100e3*24/25
  states: {}
- name: variable_qtgui_Fc
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,0,1,1]'
    label: Center Frequency (kHz)
    start: '905.5895'
    step: '0.3618'
    stop: 905.5895 + 0.3618*52
    value: '905.5895'
  states: {}
- name: variable_qtgui_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    label: Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: amr_rx_heir_0
  id: amr_rx_heir
  parameters:
    bits_per_second: '9600'
    center_freq: center_freq
    mag_trigger_level: '-15'
    period: '0.0125'
    samp_rate: samp_rate_2
  states: {}
- name: blocks_msg_meta_to_pair_0
  id: blocks_msg_meta_to_pair
  parameters:
    keyin: '''bits'''
    keyout: '''bits'''
  states: {}
- name: blocks_msg_meta_to_pair_0_0
  id: blocks_msg_meta_to_pair
  parameters:
    keyin: '''timestamp'''
    keyout: '''time'''
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    update_time: '0.01'
    ymax: '-30'
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Bits"'
    ncols: int(9600*.0125)
    samp_rate: '9600'
    type: msg_float
    update_time: '0.01'
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    size: '300'
    srate: samp_rate_2
    tr_level: mag_trigger_level
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '0'
    ymin: '-60'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    size: '300'
    srate: samp_rate_2
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    name: '"Samples"'
    srate: samp_rate_2
    type: msg_float
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    name: '"Bits"'
    srate: '9600'
    type: msg_float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    grid: 'True'
    int_max: '-20'
    int_min: '-100'
    type: complex
    update_time: '0.01'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    type: ccc
  states: {}
- name: tools_print_float_0
  id: tools_print_float
  parameters:
    enabled: 'True'
    variable_name: '''time'''
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate*N
    center_freq0: uhd.tune_request(center_freq, 50000.0)
    dc_offs_enb0: auto
    dev_addr: '"serial=3102419"'
    gain0: variable_qtgui_Gain
    iq_imbal_enb0: auto
    minoutbuf: '1000'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [amr_rx_heir_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [amr_rx_heir_0, '1', qtgui_time_sink_x_0, '0']
- [amr_rx_heir_0, bits, blocks_msg_meta_to_pair_0, inmeta]
- [amr_rx_heir_0, bits, blocks_msg_meta_to_pair_0_0, inmeta]
- [amr_rx_heir_0, bits, qtgui_time_raster_sink_x_0, in]
- [amr_rx_heir_0, samples, qtgui_time_sink_x_1, in]
- [blocks_msg_meta_to_pair_0, outpair, qtgui_time_sink_x_1_0, in]
- [blocks_msg_meta_to_pair_0_0, outpair, tools_print_float_0, msg]
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', amr_rx_heir_0, '0']
- [uhd_usrp_source_1, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
